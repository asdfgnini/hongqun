# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: usart1.c stm32f10x_it.c led.c mqtt.c usart3.c cat1.c bsp_timer.c spi.c wizchip_conf.c w5500.c dhcp.c socket.c
    H:/baiduwangpan/【模组星球】4G-STM32-物联网核心板/4配套源代码/物联网云服务器例程-阿里云智能生活平台 云智能公版APP 控制一路LED/物联网云服务器例程-阿里云智能生活平台 云智能公版APP 控制一路LED/HARDWARE/scr/: timer2.c iwdg.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_spi.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
